# Repository lowj/HE60

## KiCad design HE60/HE60.kicad_pcb

Parts:
AM1, AM2, AM3, AM4, AM5, AM6, AM7, AM8, AM9, AM10: SN74LV4051A; TSSOP-16_4.4x5mm_P0.65mm
C1, C3, C5, C7, C9, C11, C13, C15, C17, C19, C21, C23, C25, C27, C29, C31, C33, C35, C37, C39, C41, C43, C45, C47, C49, C51, C53, C55, C57, C59, C61, C63, C65, C67, C69, C71, C73, C75, C77, C79, C81, C83, C85, C87, C89, C91, C93, C95, C97, C99, C101, C103, C105, C107, C109, C111, C113, C115, C117, C119, C121, C123, C125, C127, C129, C131, C133, C135, C137, C139, C140, C141, C142, C143, C144, C145, C146, C147, C154, C155, C156, C158, C160, C161: 100n; C_0402_1005Metric
C2, C4, C6, C8, C10, C12, C14, C16, C18, C20, C22, C24, C26, C28, C30, C32, C34, C36, C38, C40, C42, C44, C46, C48, C50, C52, C54, C56, C58, C60, C62, C64, C66, C68, C70, C72, C74, C76, C78, C80, C82, C84, C86, C88, C90, C92, C94, C96, C98, C100, C102, C104, C106, C108, C110, C112, C114, C116, C118, C120, C122, C124, C126, C128, C130, C132, C134, C136, C138: 4.7n; C_0402_1005Metric
C148, C149, C150, C151: 2.2u; C_0603_1608Metric
C152, C153: 30p; C_0603_1608Metric
C157: 10u; C_0603_1608Metric
C159: 1u; C_0603_1608Metric
F1: BSMD0805-050-24V; Fuse_0805_2012Metric
HE1, HE2, HE3, HE4, HE5, HE6, HE7, HE8, HE9, HE10, HE11, HE12, HE13, HE14, HE15, HE16, HE17, HE18, HE19, HE20, HE21, HE22, HE23, HE24, HE25, HE26, HE27, HE28, HE29, HE30, HE31, HE32, HE33, HE34, HE35, HE36, HE37, HE38, HE39, HE40, HE41, HE42, HE43, HE44, HE45, HE46, HE47, HE48, HE49, HE50, HE51, HE52, HE53, HE54, HE55, HE56, HE57, HE58, HE59, HE60, HE61, HE62, HE63, HE64, HE65, HE66, HE67, HE68, HE69: MT9102ET; SOT-23-3
J1: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: SWD; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x09_MountingPin; JST_SH_SM09B-SRSS-TB_1x09-1MP_P1.00mm_Horizontal
J4: Conn_01x06_MountingPin; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX16, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX45, MX46, MX47, MX48, MX49, MX50, MX51, MX52, MX53, MX54, MX57, MX61, MX64, MX69, MX73: 1U; MX-1U
MX15: 2U; MX-2U
MX17, MX30, MX59, MX63, MX71, MX75: 1.5U; MX-1.5U
MX31, MX55: 1.75U; MX-1.75U
MX43, MX44: 2.25U; MX-2.25U
MX56: 2.75U; MX-2.75U
MX58, MX60, MX62, MX70, MX72, MX74, MX76: 1.25U; MX-1.25U
MX65: 2.25U; MX-2.25U-ReversedStabilizers
MX66: 6.25U; MX-6.25U-ReversedStabilizers
MX67: 7U; MX-7U-ReversedStabilizers
MX68: 2.75U; MX-2.75U-ReversedStabilizers
PCB1: H60
R1, R2: 5.1k; R_0402_1005Metric
R3, R4: 12k; R_0402_1005Metric
SW1, SW2: TS-1187A-B-A-B; SW_Push_1P1T_XKB_TS-1187A
TH1, TH2: ToolingHole
U1: USBLC6-2SC6; SOT-23-6
U2: TLV75733PDBV; SOT-23-5
U3: XC6206P332MR-G; SOT-23-3
U4: AT32F405RCT7; LQFP-64_10x10mm_P0.5mm
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C151.1, C154.1, C155.1, C156.1, C157.1, J2.1, SW2.2, U3.2 (VO), U4.1 (VDD), U4.36 (VDD), U4.64 (VDD)
+3.3VA: AM1.16 (VDD), AM2.16 (VDD), AM3.16 (VDD), AM4.16 (VDD), AM5.16 (VDD), AM6.16 (VDD), AM7.16 (VDD), AM8.16 (VDD), AM9.16 (VDD), AM10.16 (VDD), C1.1, C3.1, C5.1, C7.1, C9.1, C11.1, C13.1, C15.1, C17.1, C19.1, C21.1, C23.1, C25.1, C27.1, C29.1, C31.1, C33.1, C35.1, C37.1, C39.1, C41.1, C43.1, C45.1, C47.1, C49.1, C51.1, C53.1, C55.1, C57.1, C59.1, C61.1, C63.1, C65.1, C67.1, C69.1, C71.1, C73.1, C75.1, C77.1, C79.1, C81.1, C83.1, C85.1, C87.1, C89.1, C91.1, C93.1, C95.1, C97.1, C99.1, C101.1, C103.1, C105.1, C107.1, C109.1, C111.1, C113.1, C115.1, C117.1, C119.1, C121.1, C123.1, C125.1, C127.1, C129.1, C131.1, C133.1, C135.1, C137.1, C139.1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
+5V: C148.1, C150.1, F1.2, U1.5 (VBUS), U2.1 (IN), U2.3 (EN), U3.3 (VI)
AT32_RX: J4.6, U4.43 (PA10)
AT32_TX: J4.5, U4.42 (PA9)
BOOT0: R4.1, SW2.1, U4.60 (PF11/BOOT0)
GND: AM1.6 (Inh), AM1.7 (VEE), AM1.8 (VSS), AM1.12 (X3), AM2.6 (Inh), AM2.7 (VEE), AM2.8 (VSS), AM3.2 (X6), AM3.6 (Inh), AM3.7 (VEE), AM3.8 (VSS), AM4.6 (Inh), AM4.7 (VEE), AM4.8 (VSS), AM5.6 (Inh), AM5.7 (VEE), AM5.8 (VSS), AM5.15 (X2), AM6.6 (Inh), AM6.7 (VEE), AM6.8 (VSS), AM7.6 (Inh), AM7.7 (VEE), AM7.8 (VSS), AM8.6 (Inh), AM8.7 (VEE), AM8.8 (VSS), AM9.6 (Inh), AM9.7 (VEE), AM9.8 (VSS), AM10.4 (X7), AM10.6 (Inh), AM10.7 (VEE), AM10.8 (VSS), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2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
HE1: AM3.15 (X2), C2.1, HE1.2 (OUT)
HE2: AM1.15 (X2), C4.1, HE2.2 (OUT)
HE3: AM1.14 (X1), C6.1, HE3.2 (OUT)
HE4: AM1.13 (X0), C8.1, HE4.2 (OUT)
HE5: AM1.1 (X4), C10.1, HE5.2 (OUT)
HE6: AM1.2 (X6), C12.1, HE6.2 (OUT)
HE7: AM1.4 (X7), C14.1, HE7.2 (OUT)
HE8: AM1.5 (X5), C16.1, HE8.2 (OUT)
HE9: AM2.1 (X4), C18.1, HE9.2 (OUT)
HE10: AM2.2 (X6), C20.1, HE10.2 (OUT)
HE11: AM2.4 (X7), C22.1, HE11.2 (OUT)
HE12: AM2.5 (X5), C24.1, HE12.2 (OUT)
HE13: AM2.15 (X2), C26.1, HE13.2 (OUT)
HE14: AM2.14 (X1), C28.1, HE14.2 (OUT)
HE15: AM2.13 (X0), C30.1, HE15.2 (OUT)
HE16: AM2.12 (X3), C32.1, HE16.2 (OUT)
HE17: AM3.14 (X1), C34.1, HE17.2 (OUT)
HE18: AM3.13 (X0), C36.1, HE18.2 (OUT)
HE19: AM3.12 (X3), C38.1, HE19.2 (OUT)
HE20: AM3.1 (X4), C40.1, HE20.2 (OUT)
HE21: AM3.4 (X7), C42.1, HE21.2 (OUT)
HE22: AM3.5 (X5), C44.1, HE22.2 (OUT)
HE23: AM4.1 (X4), C46.1, HE23.2 (OUT)
HE24: AM4.2 (X6), C48.1, HE24.2 (OUT)
HE25: AM4.4 (X7), C50.1, HE25.2 (OUT)
HE26: AM4.5 (X5), C52.1, HE26.2 (OUT)
HE27: AM4.15 (X2), C54.1, HE27.2 (OUT)
HE28: AM4.14 (X1), C56.1, HE28.2 (OUT)
HE29: AM4.13 (X0), C58.1, HE29.2 (OUT)
HE30: AM4.12 (X3), C60.1, HE30.2 (OUT)
HE31: AM7.1 (X4), C62.1, HE31.2 (OUT)
HE32: AM5.1 (X4), C64.1, HE32.2 (OUT)
HE33: AM5.2 (X6), C66.1, HE33.2 (OUT)
HE34: AM5.4 (X7), C68.1, HE34.2 (OUT)
HE35: AM5.5 (X5), C70.1, HE35.2 (OUT)
HE36: AM5.14 (X1), C72.1, HE36.2 (OUT)
HE37: AM5.13 (X0), C74.1, HE37.2 (OUT)
HE38: AM5.12 (X3), C76.1, HE38.2 (OUT)
HE39: AM6.1 (X4), C78.1, HE39.2 (OUT)
HE40: AM6.2 (X6), C80.1, HE40.2 (OUT)
HE41: AM6.4 (X7), C82.1, HE41.2 (OUT)
HE42: AM6.5 (X5), C84.1, HE42.2 (OUT)
HE43: AM6.15 (X2), C86.1, HE43.2 (OUT)
HE44: AM7.2 (X6), C88.1, HE44.2 (OUT)
HE45: AM7.4 (X7), C90.1, HE45.2 (OUT)
HE46: AM7.5 (X5), C92.1, HE46.2 (OUT)
HE47: AM8.1 (X4), C94.1, HE47.2 (OUT)
HE48: AM8.2 (X6), C96.1, HE48.2 (OUT)
HE49: AM8.4 (X7), C98.1, HE49.2 (OUT)
HE50: AM8.5 (X5), C100.1, HE50.2 (OUT)
HE51: AM9.1 (X4), C102.1, HE51.2 (OUT)
HE52: AM9.2 (X6), C104.1, HE52.2 (OUT)
HE53: AM9.4 (X7), C106.1, HE53.2 (OUT)
HE54: AM9.5 (X5), C108.1, HE54.2 (OUT)
HE55: AM6.12 (X3), C110.1, HE55.2 (OUT)
HE56: AM6.13 (X0), C112.1, HE56.2 (OUT)
HE57: AM6.14 (X1), C114.1, HE57.2 (OUT)
HE58: AM7.15 (X2), C116.1, HE58.2 (OUT)
HE59: AM7.14 (X1), C118.1, HE59.2 (OUT)
HE60: AM7.13 (X0), C120.1, HE60.2 (OUT)
HE61: AM7.12 (X3), C122.1, HE61.2 (OUT)
HE62: AM8.12 (X3), C124.1, HE62.2 (OUT)
HE63: AM8.13 (X0), C126.1, HE63.2 (OUT)
HE64: AM8.14 (X1), C128.1, HE64.2 (OUT)
HE65: AM8.15 (X2), C130.1, HE65.2 (OUT)
HE66: AM9.12 (X3), C132.1, HE66.2 (OUT)
HE67: AM9.13 (X0), C134.1, HE67.2 (OUT)
HE68: AM9.14 (X1), C136.1, HE68.2 (OUT)
HE69: AM9.15 (X2), C138.1, HE69.2 (OUT)
HE70: AM10.12 (X3), J3.2
HE71: AM10.13 (X0), J3.3
HE72: AM10.14 (X1), J3.4
HE73: AM10.15 (X2), J3.5
HE74: AM10.5 (X5), J3.6
HE75: AM10.2 (X6), J3.7
HE76: AM10.1 (X4), J3.8
HEXT_IN: C152.1, U4.5 (PF0/HEXT_IN), Y1.1
HEXT_OUT: C153.1, U4.6 (PF1/HEXT_OUT), Y1.3
MUX_OUT_1: AM1.3 (X), U4.17 (PA3)
MUX_OUT_2: AM2.3 (X), U4.20 (PA4)
MUX_OUT_3: AM3.3 (X), U4.21 (PA5)
MUX_OUT_4: AM4.3 (X), U4.22 (PA6)
MUX_OUT_5: AM5.3 (X), U4.23 (PA7)
MUX_OUT_6: AM6.3 (X), U4.24 (PC4)
MUX_OUT_7: AM7.3 (X), U4.25 (PC5)
MUX_OUT_8: AM8.3 (X), U4.26 (PB0)
MUX_OUT_9: AM9.3 (X), U4.27 (PB1)
MUX_OUT_10: AM10.3 (X), U4.16 (PA2)
MUX_SELECT_0: AM1.11 (A), AM2.11 (A), AM3.11 (A), AM4.11 (A), AM5.11 (A), AM6.11 (A), AM7.11 (A), AM8.11 (A), AM9.11 (A), AM10.11 (A), U4.9 (PC1)
MUX_SELECT_1: AM1.10 (B), AM2.10 (B), AM3.10 (B), AM4.10 (B), AM5.10 (B), AM6.10 (B), AM7.10 (B), AM8.10 (B), AM9.10 (B), AM10.10 (B), U4.10 (PC2)
MUX_SELECT_2: AM1.9 (C), AM2.9 (C), AM3.9 (C), AM4.9 (C), AM5.9 (C), AM6.9 (C), AM7.9 (C), AM8.9 (C), AM9.9 (C), AM10.9 (C), U4.11 (PC3)
NRST: C160.1, SW1.1, U4.7 (NRST)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.2
unnamed: R3.2, U4.33 (OTGHS1_R)
SWCLK: J2.3, U4.49 (PA14)
SWDIO: J2.2, U4.46 (PA13)
USB_D+: U1.4 (I/O2), U4.35 (OTGHS1_D+)
USB_D-: U1.6 (I/O1), U4.34 (OTGHS1_D-)
USB_PLUG_D+: J1.A6 (D+), J1.B6 (D+), J4.3, U1.3 (I/O2)
USB_PLUG_D-: J1.A7 (D-), J1.B7 (D-), J4.2, U1.1 (I/O1)
VBUS: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.1

Notes on the sheet:
JST
PCB
Hall Sensors
Switches
USB
Analog Multiplexers
Power
Debug
Microcontroller

Board: 2 copper layers, 284.7 x 94.2 mm, 331 parts (248 on the bottom side), 109 nets.

## KiCad design hub/hub.kicad_pcb

Parts:
F1: Polyfuse_Small; Fuse_1812_4532Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad
J1, J2, J3, J4: Conn_01x04_Socket; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J5: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1, R2: 5.1K; C_0402_1005Metric
U1: CH334F; QFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U5: USBLC6-2SC6; SOT-23-6
Y2: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: F1.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U1.19 (V5), U5.5 (VBUS)
CC1: J5.A5 (CC1), R2.2
CC2: J5.B5 (CC2), R1.2
D1+: J1.3, U1.12 (DP1)
D1-: J1.2, U1.11 (DM1)
D2+: J2.3, U1.10 (DP2)
D2-: J2.2, U1.9 (DM2)
D3+: J3.3, U1.8 (DP3)
D3-: J3.2, U1.7 (DM3)
D4+: J4.3, U1.6 (DP4)
D4-: J4.2, U1.5 (DM4)
DU_+: U1.15 (DPU), U5.4 (I/O2)
DU_-: U1.14 (DMU), U5.6 (I/O1)
GND: J1.4, J2.4, J3.4, J4.4, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), R1.1, R2.1, U1.18 (PSELF), U1.25 (GND), U5.2 (GND), Y2.2, Y2.4
unnamed: J5.A6 (D+), J5.B6 (D+), U5.3 (I/O2)
unnamed: J5.A7 (D-), J5.B7 (D-), U5.1 (I/O1)
unnamed: U1.4 (XI), Y2.3
unnamed: U1.3 (XO), Y2.1
VBUS: F1.2, J1.1, J2.1, J3.1, J4.1

Notes on the sheet:
Is there GND for thsi symbol?

Board: 2 copper layers, 23.9 x 26.1 mm, 15 parts (0 on the bottom side), 19 nets.

## Commit log

2026-02-17 start proj + add ch334f sym
2026-03-13 sch: add another adc mux and 8 more HE sensors
2026-03-13 sch: add swd, add uart and adc channel
2026-03-22 layout: add arrows and top 3 block
2026-03-28 work
2026-03-28 resolve unconnected items
2026-04-12 update edge cuts with wkl blockers
2026-04-12 del footprints in wkl area
2026-04-12 flip stabilizer mounting holes to clear wkl blockers
2026-04-13 sch:add extra mux + channels, and JST
2026-04-13 sch: hookup uart swd mux to mcu, assign foots
2026-05-04 add models for 1u
    https://grabcad.com/library/cherry-mx-switches-mx-1
2026-05-04 add switch model for rest of keys
2026-05-05 add keycaps to 3d model
